options:
  parameters:
    author: henningM1r
    generate_options: qt_gui
    id: UK_AMDS_Receiver
    output_language: python
    title: UK-AMDS Receiver
  states: {}

blocks:
- name: decimation
  id: variable
  parameters:
    value: '24'
  states: {}
- name: freq_UKAMDS
  id: variable
  parameters:
    value: '198000'
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    label: Recv. Gain
    start: '500'
    step: '10'
    stop: '1000'
    value: '750'
  states: {}
- name: pll_bw
  id: variable_qtgui_range
  parameters:
    label: PLL Bandwidth
    start: '0.01'
    step: '0.01'
    stop: '10'
    value: '2.0'
  states: {}
- name: pll_limit
  id: variable
  parameters:
    value: '0.7853981633974483'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '192000'
  states: {}
- name: variable_low_pass_filter_taps
  id: variable_low_pass_filter_taps
  parameters:
    comment: |-
      a fairly dense bandwidth
      is required here
    cutoff_freq: '150'
    gain: '1'
    samp_rate: samp_rate
    width: '60'
    win: window.WIN_BLACKMAN
  states: {}
- name: analog_pll_carriertracking_cc_0
  id: analog_pll_carriertracking_cc
  parameters:
    comment: phase drift compensation
    max_freq: 2*math.pi*pll_limit/samp_rate
    min_freq: '-2*math.pi*pll_limit/samp_rate'
    w: 2*math.pi*pll_bw/samp_rate
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_complex_to_arg_0_0
  id: blocks_complex_to_arg
  parameters:
    comment: |-
      to obtain the
      phase of the
      complex signal
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: blocks_message_debug_0_0
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: blocks_message_debug_0_0_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_moving_average_xx_0
  id: blocks_moving_average_xx
  parameters:
    comment: slight signal smoothing
    length: '50'
    max_iter: '150'
    scale: 1/25
    type: complex
  states: {}
- name: blocks_moving_average_xx_1
  id: blocks_moving_average_xx
  parameters:
    length: '1000000'
    max_iter: '1200000'
    scale: 1/1000000
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: gain
    type: complex
  states: {}
- name: digital_binary_slicer_fb_0
  id: digital_binary_slicer_fb
  parameters:
    comment: |-
      mapping from
      -/+1 to 0/1
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: "\nfrom gnuradio import gr\nimport pmt\nimport numpy as np\n\n\n# track the seconds\n_count = 0\n\n_count_zeros = 0\n_count_ones = 0\n\n# single value history\n_msg_history = None\n\nclass blk(gr.sync_block):\n\n    def __init__(self):\n        gr.sync_block.__init__(\n            self,\n            name='Manchester-\\nDecoder',\n            in_sig=None,\n            out_sig=None\n        )\n\n        self.message_port_register_out(pmt.intern('msg_out'))\n        self.message_port_register_in(pmt.intern('msg_in'))\n        self.set_msg_handler(pmt.intern('msg_in'), self.handle_msg)\n\n        self.queue_len = 25\n        self.queue = gr.msg_queue(self.queue_len)\n\n    def prepare_window(self, msg):\n        # message contains a whole sequence of a received second\n        # but not synchronized to the frames yet\n        msg = pmt.to_python(msg)\n\n        # first put each string into an array (separated by comma)\n        received_msg = msg.split(\",\")\n\n        # truncate last element (\"\") from list\n        received_msg = received_msg[:-1]\n\n        # convert to numpy-array\n        np_recv_seq = np.array(received_msg)\n\n        # turn each array element into an integer value\n        np_recv_seq = np.asarray(np_recv_seq, dtype=np.int32)\n\n        return np_recv_seq\n\n    def convertFromManchester(self, inp):\n        global _msg_history\n\n        i = 1\n        while i <= len(inp):\n            if i == len(inp):\n                # memorize last symbol for next block\n                _msg_history = inp[i-1]\n                return\n\n            if inp[i-1] == 0 and inp[i] == 1:\n                self.send_msg(val=\"0,\")\n                i += 2\n                \n            elif inp[i-1] == 1 and inp[i] == 0:\n                self.send_msg(val=\"1,\")\n                i += 2\n\n            else: # error - no Manchester code symbol\n                if i != 0:\n                    # 00 or 11 received\n                    self.send_msg(val=\"2,\")\n                i += 1\n\n    def send_msg(self, val):\n        # convert python string to message\n        msg1_in = gr.message_from_string(val)\n\n        # insert message into queue\n        self.queue.insert_tail(msg1_in)\n\n        msg_list = [0] * self.queue_len\n\n        # send a combination of all messages contained in queue\n        if self.queue.full_p():\n            for idx in range(0, self.queue_len):\n                msg_list[idx] = self.queue.delete_head().\\\n                                     to_string().decode(\"utf-8\")\n\n            msg1_out = \"\".join(map(str, msg_list))\n            self.message_port_pub(pmt.intern(\"msg_out\"),\n                                  pmt.intern(msg1_out))\n\n    def handle_msg(self, msg):\n        global _msg_history\n\n        window = self.prepare_window(msg)\n\n        # append non-empty single-item history\n        if _msg_history != None:\n            #print(\"insert history at front: \", _msg_history)\n            window = np.insert(arr=window, obj = 0, values=_msg_history, axis=0)\n            _msg_history = None\n            #print(\"cleared history\")\n\n        self.convertFromManchester(window)\n\n"
    alias: Manchester_Decoder
    comment: |-
      convert incoming bits:
      according to
      Manchester decoding
      01 => 0
      10 => 1
  states: {}
- name: epy_block_0_0
  id: epy_block
  parameters:
    _source_code: "\nimport numpy as np\nfrom gnuradio import gr\nimport pmt\n\n\n# counted number of one samples for +1\n_num_ones = 0\n# counted number of one samples for -1\n_num_zeros = 0\n\nclass blk(gr.sync_block):\n\n    def __init__(self, sample_rate=24750):\n\n        gr.sync_block.__init__(\n            self,\n            name='UK-AMDS\\nSymbol Detector',\n            in_sig=[np.float32],\n            out_sig=[np.float32]\n        )\n\n        self.message_port_register_out(pmt.intern('msg_out'))\n\n        self.sample_rate = sample_rate\n\n        # each subframe lasts approx. 20ms\n        self._subframe = int(0.02 * self.sample_rate)\n\n        print(\"subframe: \", self._subframe)\n\n        self.queue_len = 25\n        self.queue = gr.msg_queue(self.queue_len)\n\n    def work(self, input_items, output_items):\n        inp = input_items[0]\n\n        output_items[0][:] = self.extract_bits(inp)\n\n        # transmit tagged stream\n        return len(output_items[0])\n\n    def clear_counters(self):\n        global _num_ones\n        global _num_zeros\n\n        _num_ones = 0\n        _num_zeros = 0\n\n    def send_msg(self, val, num):\n        # handles both the message ouput queue\n        # and the message transmission\n        _msg = \"\"\n\n        if num > 0:\n            for i in range(0, num):\n                _msg += val\n\n            # convert python string to message\n            msg1_in = gr.message_from_string(_msg)\n\n            # insert message into queue\n            self.queue.insert_tail(msg1_in)\n\n        msg_list = [0]*self.queue_len\n\n        # send a combination of all messages contained in queue\n        if self.queue.full_p():\n            for idx in range(0, self.queue_len):\n                msg_list[idx] = self.queue.delete_head().\\\n                                     to_string().decode(\"utf-8\")\n\n            msg1_out = \"\".join(map(str, msg_list))\n            self.message_port_pub(pmt.intern(\"msg_out\"),\n                                  pmt.intern(msg1_out))\n\n    def extract_bits(self, inp):\n        global _num_ones\n        global _num_zeros\n\n        out = np.zeros(len(inp))\n\n        # iterate through all five (parallel) input streams concurrently\n        for idx in range(len(inp)):\n            # get symbol value at index for input stream\n            ch = inp[idx]\n\n            # increment current counters of ones per\n            # input stream, correspondingly\n            if ch == 1:\n                _num_ones += 1\n\n            if ch == 0:\n                _num_zeros += 1\n\n            # changes from 1 to 0\n            if (ch == 0 and\n                    _num_ones >= int(self._subframe*0.66)):\n\n                _num = round(_num_ones/self._subframe)\n\n                key = pmt.intern(\"\")\n                value = pmt.intern(f\"1,{_num}\")\n                self.add_item_tag(0,\n                                  self.nitems_written(0) + idx,\n                                  key,\n                                  value)\n\n                out[idx] = 0.25\n                self.send_msg(val=\"1,\", num=_num)\n\n                self.clear_counters()\n\n            # changes from 0 to 1\n            if (ch == 1 and\n                    _num_zeros >= int(self._subframe*0.66)):\n\n                _num = round(_num_zeros/self._subframe)\n\n                key = pmt.intern(\"\")\n                value = pmt.intern(f\"0,{_num}\")\n                self.add_item_tag(0,\n                                  self.nitems_written(0) + idx,\n                                  key,\n                                  value)\n\n                out[idx] = -0.25\n                self.send_msg(val=\"0,\", num=_num)\n\n                self.clear_counters()\n\n        return out\n"
    alias: UK_AMDS_Symbol_Detector
    comment: |-
      detects symbols
      with the values 1/0
      and provides
      corresponding
      messages, respectively.
    sample_rate: int(samp_rate/decimation)
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: "\nimport numpy as np\nfrom gnuradio import gr\nimport pmt\nfrom scipy.spatial.distance import hamming\n\n\n# sliding window for selected messages\n_msg_window = np.empty(shape=(1, 1))\n\nclass blk(gr.sync_block):\n\n    def __init__(self):\n        gr.sync_block.__init__(\n            self,\n            name='UK-AMDS\\nCorrelator',\n            in_sig=None,\n            out_sig=None,\n        )\n\n        self.message_port_register_out(pmt.intern('msg_out'))\n        self.message_port_register_in(pmt.intern('msg_in'))\n        self.set_msg_handler(pmt.intern('msg_in'), self.handle_msg)\n\n        # codes and headers\n        self.filler_code = [1,0,0,0,0,1,0,1,0,1,0,1,0,1,0,1,0,\n                            1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,\n                            0,1,0,1,0,0,0,1,0,1,1,1,1,1,0,1]\n\n        self.time_code_header = [1,0,0,0,0,0]\n\n        self.other_app_header1 = [1,0,1,0,1,1]\n        self.other_app_header2 = [1,0,1,0,1,0]\n        self.other_app_header3 = [1,1,1,1,0,1]\n\n        self.symbol_thres = 0\n\n    def prepare_window(self, msg):\n        global _msg_window\n\n        # message contains the whole sequence of a received second\n        msg = pmt.to_python(msg)\n\n        # first put each string into an array (separated by comma)\n        received_msg = msg.split(\",\")\n\n        # truncate last element (\"\") from list\n        received_msg = received_msg[:-1]\n\n        # convert to numpy-array\n        np_recv_seq = np.array(received_msg)\n\n        # turn each array element into an integer value\n        np_recv_seq = np.asarray(np_recv_seq, dtype=np.int32)\n\n        _msg_window = np.append(_msg_window, np_recv_seq)\n\n    def compare_code(self, window, code, cw_len):\n        min_dist = cw_len\n        idx = 0\n        found = False\n\n        # decision metric: compare window with codeword\n        # using the Hamming metric\n        for offset in range(0, max(1, len(window) - cw_len + 1)):\n            dist = hamming(window[offset:offset + cw_len], code)\n\n            # update current minimum\n            if min_dist > dist:\n                min_dist = dist\n\n            # check decision threshold for minimum\n            if min_dist <= self.symbol_thres:\n                idx = offset\n                break\n\n        if min_dist <= self.symbol_thres:\n            # this is indeed a filler-code\n            found = True\n\n        if min_dist > self.symbol_thres:\n            # this is not a filler-code\n            found = False\n\n        return [found, idx]\n\n    def handle_msg(self, msg):\n        global _msg_window\n\n        # find beginning of block\n        # send full block out to decoder\n        # 2 indicates loss\n\n        self.prepare_window(msg)\n\n        found = False\n\n        if len(_msg_window) >= 75:\n            cur_window = _msg_window.copy()\n\n            # find position-codeword in _msg_window\n            [filler_found, idx] = \\\n                self.compare_code(\n                window=_msg_window.copy(),\n                code=self.filler_code,\n                cw_len=50)\n\n            if filler_found == True:\n                filler_code = _msg_window[idx:idx+50]\n                #print(f\"Window: {cur_window.astype(int)}\")\n                print(f\"filler-code found at {idx}\")\n\n                # send message\n                msg1_out = np.array2string(filler_code.astype(int), separator=',')\n                self.message_port_pub(pmt.intern(\"msg_out\"),\n                                      pmt.intern(msg1_out))\n\n                # truncate decoded filler window\n                _msg_window = _msg_window[idx+50:]\n\n                return\n\n            window_header = list(_msg_window[0:6].astype(int))\n\n            if window_header == self.time_code_header:\n                time_code = _msg_window[idx:idx+50]\n                #print(f\"Window: {cur_window.astype(int)}\")\n                print(f\"time-header at 0: {self.time_code_header}\")\n                #print(f\"full time-code: {time_code.astype(int)}\")\n\n                # send message\n                msg1_out = np.array2string(time_code.astype(int), separator=',')\n                self.message_port_pub(pmt.intern(\"msg_out\"),\n                                      pmt.intern(msg1_out))\n\n                # truncate window\n                _msg_window = _msg_window[50:]\n\n                return\n\n            if (window_header == self.other_app_header1 or\n                    window_header == self.other_app_header2 or\n                    window_header == self.other_app_header3):\n                other_code = _msg_window[idx:idx+50]\n                #print(f\"Window: {cur_window.astype(int)}\")\n                print(f\"Detected other application code at 0.\")\n                print(f\"header code: {window_header}\")\n\n                # send message\n                msg1_out = np.array2string(other_code.astype(int), separator=',')\n                self.message_port_pub(pmt.intern(\"msg_out\"),\n                                      pmt.intern(msg1_out))\n                # truncate window\n                _msg_window = _msg_window[50:]\n\n                return\n\n            else:\n                #print(f\"Window: {cur_window.astype(int)}\")\n                print(\"Codeword unknown - out of sync\")\n\n                # truncate part of window\n                _msg_window = _msg_window[24:]\n\n\n"
    alias: UK_AMDS_Correlator
    comment: |-
      detect filler_code
      detect time_code_header
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '0'
    decim: '1'
    samp_rate: samp_rate
    taps: variable_low_pass_filter_taps
    type: ccc
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: note_0
  id: note
  parameters:
    comment: |-
      public specification of UK-AMDS
      * UK-AMDS signals
      * time code
      * filler code
      https://www.sigidwiki.com/images/2/29/1984-19.pdf
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: airspyhf=0
    bb_gain0: '0'
    bw0: '4000'
    comment: |-
      frame is localized on the
      center frequency of the
      UK-AMDS signal
    dc_offset_mode0: '2'
    freq0: freq_UKAMDS
    gain0: '30'
    gain_mode0: 'False'
    if_gain0: '30'
    sample_rate: samp_rate
    sync: none
    type: fc32
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: (1,0)
    label1: Phase Signal
    label2: Binary Levels
    label3: TIme-Sliced Levels
    nconnections: '3'
    size: int(samp_rate/decimation)
    srate: samp_rate
    type: float
    update_time: '0.025'
    ymax: '1.25'
    ymin: '-0.5'
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    gui_hint: (2,0)
    label1: Recv. Power
    size: '1024'
    srate: samp_rate
    type: float
    update_time: '0.025'
    ymax: '1.5'
    ymin: '-0.25'
  states: {}
- name: rational_resampler_xxx_1
  id: rational_resampler_xxx
  parameters:
    comment: |-
      to reduces receiver
      complexity
    decim: decimation
    interp: '1'
    type: ccc
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: '0'
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: '0'
  states: {}
- name: zeromq_push_msg_sink_0
  id: zeromq_push_msg_sink
  parameters:
    address: tcp://127.0.0.1:55555
    comment: to UK-AMDS decoder
    timeout: '100'
  states: {}

connections:
- [analog_pll_carriertracking_cc_0, '0', virtual_sink_0, '0']
- [blocks_char_to_float_0, '0', epy_block_0_0, '0']
- [blocks_char_to_float_0, '0', qtgui_time_sink_x_0, '1']
- [blocks_complex_to_arg_0_0, '0', digital_binary_slicer_fb_0, '0']
- [blocks_complex_to_arg_0_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_complex_to_mag_squared_0, '0', blocks_moving_average_xx_1, '0']
- [blocks_moving_average_xx_0, '0', blocks_complex_to_arg_0_0, '0']
- [blocks_moving_average_xx_1, '0', qtgui_time_sink_x_1, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_complex_to_mag_squared_0, '0']
- [blocks_multiply_const_vxx_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [digital_binary_slicer_fb_0, '0', blocks_char_to_float_0, '0']
- [epy_block_0, msg_out, blocks_message_debug_0_0, print]
- [epy_block_0, msg_out, epy_block_1, msg_in]
- [epy_block_0_0, '0', qtgui_time_sink_x_0, '2']
- [epy_block_0_0, msg_out, blocks_message_debug_0, print]
- [epy_block_0_0, msg_out, epy_block_0, msg_in]
- [epy_block_1, msg_out, blocks_message_debug_0_0_0, print]
- [epy_block_1, msg_out, zeromq_push_msg_sink_0, in]
- [freq_xlating_fir_filter_xxx_0, '0', rational_resampler_xxx_1, '0']
- [osmosdr_source_0, '0', blocks_multiply_const_vxx_0, '0']
- [rational_resampler_xxx_1, '0', analog_pll_carriertracking_cc_0, '0']
- [virtual_source_0, '0', blocks_moving_average_xx_0, '0']

metadata:
  file_format: 1
